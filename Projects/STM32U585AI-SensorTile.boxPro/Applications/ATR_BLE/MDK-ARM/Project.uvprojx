# Keil uVision project Project.uvprojx, settings and files
target ATR_BLE (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IROM(0x08000000-0x80FDFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: ATR_BLE +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format
  c include: ../Inc;../PnPL/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-LP/includes;../../../../../Middlewares/ST/BlueNRG-LP/utils;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;..\..\..\..\..\Middlewares\ST\PnPLCompManager\Inc;../../../../../Middlewares/Third_Party/parson;../../../../../Drivers/BSP/SensorTileBoxPro;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/lsm6dsv16x;../../../../../Drivers/BSP/Components/lps22df;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/Components/ST25DV;..\..\..\..\..\Drivers\BSP\Components\st25dvxxkc;../STSmartNFC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: App_model.c BLE_Implementation.c hci_tl_interface.c LogControl.c main.c OTA.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Application/User/PnPL
    ../PnPL/Src/: Control_PnPL.c Deviceinformation_PnPL.c Lps22df_Press_PnPL.c Lsm6dsv16x_Mlc_PnPL.c Lsm6dsv16x6d_Acc_PnPL.c Lsm6dsv16xwu_Acc_PnPL.c Stts22h_Temp_PnPL.c
  group Application/User/STSmartNFC
    ../STSmartNFC/Src/: LogFlashControl.c SmartNFC.c TagType5.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/lps22df
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
  group Drivers/Components/lsm6dsv16x
    ../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x.c lsm6dsv16x_reg.c
  group Drivers/Components/stts22h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/Components/st25dv
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/Components/st25dvxxkc
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/SensorTileboxPro
    ../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro.c SensorTileBoxPro_bus.c SensorTileBoxPro_env_sensors.c SensorTileBoxPro_env_sensors_ex.c SensorTileBoxPro_motion_sensors.c SensorTileBoxPro_motion_sensors_ex.c SensorTileBoxPro_nfctag.c SensorTileBoxPro_nfctag_ex.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_BinaryContent.c BLE_Manager.c BLE_PnPLike.c
  group Middlewares/BlueNRG-LP/Documentation
    ../../../../../Middlewares/ST/BlueNRG-LP/doc/: BlueNRG-LP_UserManual.txt
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Controller
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/controller/: bluenrg_lp_gap_aci.c bluenrg_lp_gatt_aci.c bluenrg_lp_hal_aci.c bluenrg_lp_l2cap_aci.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/: bluenrg_lp_devConfig.c bluenrg_lp_events.c bluenrg_lp_events_cb.c bluenrg_lp_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Utils
    ../../../../../Middlewares/ST/BlueNRG-LP/utils/: ble_list.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/PnPLManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
software components: CMSIS:CORE 5.6.0
